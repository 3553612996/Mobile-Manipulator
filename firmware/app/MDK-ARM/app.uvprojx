# Keil uVision project app.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: app +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../03_Platform/platform_common;../03_Platform/platform_mcu;../03_Platform/platform_bsp;../03_Platform/platform_os;../03_Platform/platform_middleware;../04_Impl;../06_BSP;../01_APP;../02_Service;../05_Middlewares;../05_Middlewares/protocol
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c freertos.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Platform/MCU
    ../03_Platform/platform_mcu/: platform_mcu_adc.c platform_mcu_encoder.c platform_mcu_gpio.c platform_mcu_pwm.c platform_mcu_timer.c platform_mcu_uart.c platform_mcu_spi.c
  group Impl/Wrapper
    ../04_Impl/impl_wrapper/: impl_adc_wrapper.c impl_encoder_wrapper.c impl_gpio_wrapper.c impl_pwm_wrapper.c impl_timer_wrapper.c impl_uart_wrapper.c impl_spi_wrapper.c
  group Impl/MCU
    ../04_Impl/impl_mcu/: impl_mcu_adc.c impl_mcu_encoder.c impl_mcu_gpio.c impl_mcu_pwm.c impl_mcu_timer.c impl_mcu_uart.c impl_mcu_spi.c impl_mcu_time.c
  group Impl/BSP
    ../04_Impl/impl_bsp/: impl_bsp_battery.c impl_bsp_buzzer.c impl_bsp_flash.c impl_bsp_key.c impl_bsp_led.c impl_bsp_motor.c impl_bsp_servo.c
  group Impl/Board
    ../04_Impl/impl_board/: board_init.c
  group BSP/Drivers
    ../06_BSP/: bsp_battery_adc.c bsp_buzzer_gpio.c bsp_flash_w25q64.c bsp_key_gpio.c bsp_led_gpio.c bsp_motor_dual_pwm.c bsp_servo_softpwm.c
  group Platform/Middleware
    ../03_Platform/platform_middleware/: platform_crc.c platform_ringbuf.c platform_filter.c platform_pid.c platform_wearlevel.c platform_logstore.c
  group Middleware/Protocol
    ../05_Middlewares/protocol/: protocol_def.c protocol_codec.c
  group Impl/OS
    ../04_Impl/impl_os/: impl_os.c
  group Service
    ../02_Service/service_key/: service_key.c
    ../02_Service/service_chassis/: service_chassis.c
    ../02_Service/service_arm/: service_arm.c
    ../02_Service/service_proto/: service_proto.c
    ../02_Service/service_storage/: service_storage.c
  group App
    ../01_APP/app_robot/: app_battery.c app_fault.c app_handlers.c app_params.c app_report.c app_robot.c app_state.c app_storage.c app_tasks.c app_user_init.c app_motion_test.c
software components: CMSIS:CORE 4.3.0
